# Autodesk Inventor assembly: Modules Weldment (ISO)
Saved by Autodesk Inventor 2014 (Build 180170000, 170)
## iProperties
Created: 2013-05
Part Number: Modules Weldment (ISO)
Document SubType Name: Weldment
Designer: Wally
Weld Material: Welded Aluminum-6061
Author: Wally
## Documents named in this file (1)
- C:\CAD Courses\Inventor\Templates\Metric Templates\Modules Weldment (ISO).iam
