# Autodesk Inventor assembly: Module w Assembly (mm)
## iProperties
Created: 2006-10
Part Number: Module w Assembly (mm)
Document SubType Name: Assembly
Designer: Wally Jones
Author: Wally Jones
