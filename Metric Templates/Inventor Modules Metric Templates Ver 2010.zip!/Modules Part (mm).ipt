# Autodesk Inventor part: Modules Part (mm)
## iProperties
Created: 2008-05
Part Number: Modules Part (mm)
Document SubType Name: Modeling
Designer: Wally
Density: 1 g/cm^3
Author: Wally
