# Autodesk Inventor part: Module Part (mm)
## iProperties
Created: 2006-10
Part Number: Module Part (mm)
Document SubType Name: Modeling
Designer: Wally Jones
Author: Wally Jones
